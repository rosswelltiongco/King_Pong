# Keil uVision project InputOutput.uvproj, settings and files
target project (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: project.c Console.h Display.h FanController.h HAL.h HAL_ADC.h HAL_Flash.h HAL_GPIO.h HAL_PLL.h HAL_PWM.h HAL_SPI.h HAL_SysTick.h HAL_Timer.h HAL_UART.h Strings.h TemperatureSettings.h Thermistor.h tm4c123gh6pm.h
    ./src/: Console.c Display.c FanController.c HAL_ADC.c HAL_Flash.c HAL_GPIO.c HAL_PLL.c HAL_PWM.c HAL_SPI.c HAL_SysTick.c HAL_Timer.c HAL_UART.c Strings.c Thermistor.c
